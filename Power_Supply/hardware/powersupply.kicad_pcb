# Repository krsandwich/Circuit_Snacks (continued)

## KiCad design Wave_Generator/wavegenerator/wavegenerator.kicad_pcb (continued)

Board: 2 copper layers, 90.1 x 60.0 mm, 59 parts (0 on the bottom side), 34 nets.

## KiCad design Wave_Generator/wavegenerator_verson_1/wavegenerator_v1.kicad_pcb

Board: 2 copper layers, 90.1 x 60.0 mm, 61 parts (0 on the bottom side), 34 nets.

Parts:
C1, C2: 100uF; CP_Radial_D8.0mm_P2.50mm
C3, C10: 4.7uF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C4, C6, C11: 1uF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C5, C7: 10nF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C8: 470pF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C9: 47nF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C101, C102: 100nF; C_0805_2012Metric
C103: 560pF; C_0805_2012Metric
C104, C105: 12pF; C_0805_2012Metric
C106, C107: 1uF; C_0805_2012Metric
D1: 1N5819; D_SOD-123
H1, H2, H3, H4: 2.1mm; MountingHole_3.2mm_M3
J1: 01x05; 01x05_pin_header
J2: USB_B_Micro; USB_Micro-B_Amphenol_10118194-0001LF_Horizontal
J3: Conn_Coaxial; BNC_connector_731000105
J4: 1x2Pinheader; PinSocket_1x02_P2.54mm_Vertical
L1: 82uH; L_7.3x7.3_H3.5
MOD1: TFT_LCD; TFT_LCD_ST7735
R1, R2: 51; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 4.87k 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 1.5M 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 180k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7, R8, R9: 560; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R101: 0.24; R_0805_2012Metric
R102: 3.32k; R_0805_2012Metric
R103, R104: 10k; R_0805_2012Metric
RV1: 1M; Potentiometer_PTV09A
RV2: 20k; Potentiometer_PTV09A
RV3: 1k; Potentiometer_PTV09A
SW1, SW2: button; SW_PUSH_6mm
SW3: SP3T; SP3T_OS103011MS8QP1
TP1: 3.3 V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP2: freq; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP3: -5V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP4: +5 V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP5: WS_0; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP6: WS_1; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP7: output; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP8: GND; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
U1: AZ1117E-3.3; SOT-223-3_TabPin2
U2: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U3: MC33063AD; SOIC-8_3.9x4.9mm_P1.27mm
U4: MAX038CPP; MAX038CPP-W
Y1: 16MHz; Crystal_SMD_ECS_CSM3X-2Pin_7.6x4.1mm

Connections:
+3V3: C102.2, C107.1, MOD1.2, MOD1.8, R1.1, R104.1, TP1.1, U1.2, U2.4, U2.6, U2.18
+5V: C1.1, C4.1, C5.2, C106.1, J2.1, R101.2, TP4.1, U1.3, U3.6, U4.17
-5V: C2.2, C6.1, C7.2, C103.2, D1.2, R102.2, TP3.1, U3.4, U4.20
/CS: MOD1.7, U2.32
/DC: MOD1.6, U2.1
/MISO: J1.1, U2.16
/MOSI: J1.3, MOD1.4, U2.15
/SCK: J1.2, MOD1.3, U2.17
/WS_0: TP5.1, U2.10, U4.3
/WS_1: TP6.1, U2.11, U4.4
/freq: C3.1, R1.2, R2.1, TP2.1, U2.9, U2.12
/output: C3.2, R8.1, RV3.3, TP7.1, U4.19
/reset: J1.4, R104.2, SW2.1, U2.29
/reset_lcd: MOD1.5, U2.28
/switch_n: SW1.1, U2.2
GND: C1.2, C2.1, C4.2, C5.1, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C101.2, C102.1, C104.1, C105.2, C106.2, C107.2, J1.5, J2.5, J2.6, J3.2, J4.2, L1.2, MOD1.1, R2.2, R7.2, R103.2, RV3.1, SW1.2, SW2.2, TP8.1, U1.1, U2.3, U2.5, U2.21, U4.2, U4.6, U4.8, U4.9, U4.11, U4.12, U4.13, U4.15, U4.18
unnamed: C8.1, SW3.4
unnamed: C9.1, SW3.3
unnamed: C10.1, SW3.1
unnamed: C11.1, R4.2, R6.1, RV1.1, RV1.2, U4.1
unnamed: C101.1, U2.20
unnamed: C103.1, U3.3
unnamed: C104.2, U2.7, Y1.2
unnamed: C105.1, U2.8, Y1.1
unnamed: D1.1, L1.1, U3.2
unnamed: J3.1, J4.1, R9.1
unnamed: R3.1, U4.10
unnamed: R3.2, R4.1, RV1.3
unnamed: R5.1, R6.2, RV2.3
unnamed: R5.2, RV2.1, RV2.2, U4.7
unnamed: R7.1, R8.2, R9.2, RV3.2
unnamed: R101.1, U3.1, U3.7, U3.8
unnamed: R102.1, R103.1, U3.5
unnamed: SW3.2, U4.5

## Code that names these connections

File Power_Supply/firmware/CircuitSnacksPowerSupply/src/CircuitSnacksPowerSupply/CircuitSnacksPowerSupply.h:

#include "Arduino.h"
#include "EEPROM.h"

/*
 * Driver for the Circuit Snacks Power Supply hardware.
 * Anything that deals with hardware details other than the joystick should go here.
 */

#define USER_LED_PIN PC13

#define V_BOOST_CTRL_PWM_PIN PA1 // Timer 2.2
#define V_BOOST_CTRL_PWM_CHANNEL 2
#define V_CURR_LIM_PWM_PIN PA2 // Timer 2.3
#define V_CURR_LIM_PWM_CHANNEL 3
#define V_LIN_CTRL_PWM_PIN PA3 // Timer 2.4
#define V_LIN_CTRL_PWM_CHANNEL 4

#define V_CURRENT_AMPLIFIED_PIN PB0 // PA0
#define V_POSITIVE_OUT_DIV_PIN PA6

#define ANALOG_READ_MAX 1024

#define EEPROM_ADDRESS_VOLTAGE_READBACK_SLOPE_CAL 0
#define EEPROM_ADDRESS_VOLTAGE_SET_SLOPE_CAL 4
#define EEPROM_ADDRESS_CURRENT_READBACK_OFFSET_CAL 8
#define EEPROM_ADDRESS_CURRENT_READBACK_SLOPE_CAL 12
#define EEPROM_ADDRESS_CURRENT_LIMIT_OFFSET_CAL 16
#define EEPROM_ADDRESS_CURRENT_LIMIT_SLOPE_CAL 20

const uint32_t FILTER_LENGTH = 11;

class CircuitSnacksPowerSupply 
{
    public:
        CircuitSnacksPowerSupply();
        
        float getMeasuredVoltage();
        float getMeasuredCurrent();
        void setOutputVoltage(float Vout);
        void setOutputCurrent(float Iout);
        
        void startVoltageCal();
        void finishVoltageCal(float measured_volts);
        void startCurrentCal();
        void finishCurrentCal(float measured_amps);

        uint32_t voltageAdjust; 
        uint32_t currentAdjust;

        uint32_t voltage;
        uint32_t current;
        
    private:
        static void Timer1_OverflowCallback(HardwareTimer* t);
        
        uint16_t measuredVoltageRawCircularBuffer[FILTER_LENGTH];
        uint16_t measuredCurrentRawCircularBuffer[FILTER_LENGTH];
        uint32_t measuredVoltageRawCircularBufferIndex;
        uint32_t measuredCurrentRawCircularBufferIndex;
        
        static float measuredVoltageFiltered;
        static float measuredCurrentFiltered;
        
        float voltageReadbackSlopeCal;
        float voltageSetSlopeCal;
        
        float currentReadbackOffsetCal;
        float currentReadbackSlopeCal;
        float currentLimitOffsetCal;
        float currentLimitSlopeCal;
        
        // User for generating interrupt to measure voltage/current
        HardwareTimer *Timer1;
        
        // Used for PWM DAC generation
        HardwareTimer *Timer2;

    
};

File Power_Supply/firmware/CircuitSnacksPowerSupply/CircuitSnacksPowerSupply.ino (part):

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#define DISPLAY_HEIGHT 64

// Incorrect labels in schematic - joystick is rotated from how symbol was drawn
#define BUTTON_UP_N_PIN PB15 //PB12 in schematic
#define BUTTON_DOWN_N_PIN PB13 //PB14 in schematic
#define BUTTON_CENTER_N_PIN PA8
#define BUTTON_RIGHT_N_PIN PB14 //PB15 in schematic
#define BUTTON_LEFT_N_PIN PB12 //PB13 in schematic

#define CURRENT_MODE 1
#define VOLTAGE_MODE 0
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   right.curr = digitalRead(BUTTON_RIGHT_N_PIN);
   down.curr = digitalRead(BUTTON_DOWN_N_PIN);
   left.curr = digitalRead(BUTTON_LEFT_N_PIN);
   center.curr = digitalRead(BUTTON_CENTER_N_PIN);
   
   if(up.prev && !up.curr)
   {
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  const int CURSOR_POSITION_MIN_VOLTS = -2;
  const float MEASURED_VOLTAGE_MAX = 20.0;
  const float MEASURED_VOLTAGE_MIN = 0.0;
  while(digitalRead(BUTTON_CENTER_N_PIN)) // press center button for next
  {
    // update the states of the joystick (except center)
    up.curr = digitalRead(BUTTON_UP_N_PIN);
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  const int CURSOR_POSITION_MIN_CURRENT_MA = 0;
  const float MEASURED_CURRENT_MAX = 0.2;
  const float MEASURED_CURRENT_MIN = 0.0;
  while(digitalRead(BUTTON_CENTER_N_PIN)) // press center button for next
  {
    // update the states of the joystick (except center)
    up.curr = digitalRead(BUTTON_UP_N_PIN);
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
## Commit log

2019-07-15 added Wave Generator
2019-07-15 fixed grammar
2019-07-15 added oscilloscope
2019-07-15 added BOM
2019-07-15 edited BOM
2019-07-15 same as last
2019-07-15 structural changes
2019-07-15 added instructions
2019-07-15 write message here about edits
2019-07-18 started power supply
2019-07-18 added to schematic
2019-07-20 schematic changes
2019-07-20 OP AMP ERRORS
2019-07-24 wavegenerator changes
2019-07-26 touch ups
2019-07-26 pwr supply changes
2019-07-30 removed op amp and sync connection
2019-07-30 naming
2019-07-30 numbering
2019-07-30 adding 1nF capacitors
2019-07-30 Updated layout
2019-07-30 adding footprint of new pots
2019-07-31 big changes
2019-07-31 layout
2019-08-01 Version 2
2019-08-03 Power supply schematic version 1
2019-08-03 small changes
2019-08-05 samd10 changes
2019-08-05 arduino change
2019-08-05 naming changes
2019-08-06 basic changes
2019-08-06 small change
2019-08-06 big change
2019-08-06 nothing...
2019-08-07 Footprints added
2019-08-07 Started layout
2019-08-07 layout changes
2019-08-07 more layout
2019-08-07 edge-cuts svg
2019-08-07 even more layout
2019-08-07 almost finished layout
2019-08-07 check
2019-08-08 small layout changes
2019-08-08 library stuff
2019-08-08 finalish changes
2019-08-08 new layout
2019-08-09 function generator schematic changes
2019-08-09 some layout changes
2019-08-09 new layout for power supply
2019-08-10 new layout with SMD components
2019-08-10 finished layout
2019-08-12 renumbered
2019-08-12 finished
2019-08-12 little layout changes
2019-08-12 things
2019-08-12 finished the layout
2019-08-12 finished power supply
2019-08-13 here
2019-08-13 fixed labels
2019-08-13 oscilloscope instructions
2019-08-14 schematic is pretty now
2019-08-19 mistakes
2019-08-19 Finished footprint
2019-08-20 logo
2019-08-21 Logos
2019-08-21 logo on arduino bootup
2019-08-21 logo readme for future bitmaps
2019-08-23 power supply layout updates
2019-08-23 does this work
2019-08-24 added arduino code
2019-08-24 everything
2019-08-26 Power Supply current sensing and limiting
2019-09-27 processor change.. such is life
2019-10-07 power supply changes
2019-10-07 pin headers
2019-10-07 save problems
2019-10-09 tiny changes
2019-10-09 labels
2019-10-14 Finished final changes and exported gerbers
    Finished final changes and exported gerbers
2019-10-14 Added fiducials for automated assembly
    Added fiducials for automated assembly
2019-10-14 small logo
2019-10-14 logo changes
2019-10-15 Generated gerbers for submission to fab
    Generated gerbers for submission to fab
2019-10-21 re-generated gerbers
    re-generated gerbers
2019-11-04 bug 1/3
2019-11-11 Fixed directional button (for real this time?)
    Also laid out pullup resistor to make bootloader happy.
2019-12-04 fill updated?
2019-12-09 Stuff for bootloader and MOSFET flat orientation
    Moved power stuff to left and changed mosfet to flat orientation
    Added LED for bootloader
    Added button for entering bootloader mode
2019-12-09 Ran DRC and fixed a rogue trace
    Ran DRC
2019-12-09 Labelled buttons
    Labelled buttons
2020-01-17 updated net name for v_positive_out_div
    updated net name for v_positive_out_div
2020-01-23 Updated current sense amplifier part number
    Didn’t include gain specifier.
2020-01-23 Reorganized power supply project into hardware and firmware folders, added firmware skeleton
    Reorganized power supply project into hardware and firmware folders,
    added firmware skeleton
2020-01-24 Moved current sense amplifier away from switching components.
    Moved current sense amplifier away from switching components.
    Moved boost converter filtering components nearer to the output of the
    boost converter.
    Moved P-MOSFET down a bit so it’s farther away from the joystick.
    Firmware: V_current_amplified moved to PB0
2020-01-24 Moved label changes to PCB, generated gerbers
    Moved label changes to PCB, generated gerbers
2020-01-29 minor
2020-01-29 display
2020-01-29 code stuff
2020-01-29 more code
2020-01-29 gross functionality
2020-01-29 code that doesnt work
2020-01-29 Updated pin name defines
    Updated pin name defines
2020-01-29 Converted control voltage calculation stuff to float math
    Converted control voltage calculation stuff to float math
2020-02-01 Tested current measurement on updated PCB
    Tested current measurement on updated PCB
2020-02-04 fixed library, set up fast PWM (see PowerSupply library)
    - Library had to be moved into “src” folder for Arduino to compile it
    properly.
    - Figured out how to use hardware timers to generate ~60 kHz PWM for
    DACs. See library for implementation.
    - Moved voltage setting code to library to test fast PWM.
2020-02-04 Interrupt based voltage/current measurement + filtering
    Implemented interrupt based voltage and current measurement so that it
    can be read and filtered in the background independent of the UI loop.
    The hacky IIR filter is probably not ideal but seems okay for now.
2020-02-10 fonts
2020-02-10 underline attempt 1
2020-02-10 underline attempt 2
2020-02-10 code done
2020-02-19 Updated some comments and function prototypes
    see title
2020-02-19 Implemented setting current limit and all calibration functions
    Implemented setting current limit and all calibration functions.
2020-02-19 Renamed confusing variables, added current setpoint, fixed display of current
    Renamed confusing variables, added current setpoint, fixed display of
    current
2020-02-19 Removed UI variables from power supply library
    Removed UI variables from power supply library
2020-02-19 Fixed: output was not quite zero when set to zero, glitch at output on powerup
    Fixed: output was not quite zero when set to zero, glitch at output on
    powerup
2020-02-19 Implemented saving calibration values to non-volatile storage
    Implemented saving calibration values to non-volatile storage
2020-02-19 Implemented a basic UI for performing calibration
    Implemented a basic UI for performing calibration
2020-02-26 UI fixes & logo attempt
2020-02-26 some changes, logo looks BAD
2020-03-04 UI change

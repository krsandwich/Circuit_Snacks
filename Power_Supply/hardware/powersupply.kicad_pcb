# Repository krsandwich/Circuit_Snacks

File README.md:

# LabBench2.0
Low-cost, minimal power DIY lab equipment

## Details
This project consists of DIY 3 different modules for any engineer's perfect lab bench

* Oscilloscope 
* Wave Generator
* Variable Power Supply

## KiCad design Power_Supply/hardware/powersupply.kicad_pcb

Parts:
C1, C2: 100uF; CP_Radial_D6.3mm_P2.50mm
C3: 270pF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C4, C5: 470uF; CP_Radial_D10.0mm_P5.00mm
C101, C102, C114: 1uF; C_0805_2012Metric
C103, C104, C106: 15uF; C_0805_2012Metric
C105, C110, C111, C112, C113: .1uF; C_0805_2012Metric
C107: .1 uF; C_0805_2012Metric
C108, C109: 15pF; C_0805_2012Metric
C115: 10uF; C_0805_2012Metric
D1, D2: 1N5819; D_DO-41_SOD81_P7.62mm_Horizontal
D101, D102: C503B 2.1V; LED_0805_2012Metric
FB101: ind; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: M4; MountingHole_3.2mm_M3
J1: 1x2; Banana Sockets
J2: 1x2; PinHeader_1x02_P2.54mm_Horizontal
J101: USB_B_Micro; USB_Micro-B_Amphenol_10118194-0001LF_Horizontal
J102: Conn_01x03_Male; PinSocket_1x03_P2.54mm_Vertical
J103, J104: Default_Jumper
L1: 47uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
L2: 1uH; 11R102C_Inductor
MOD1: TFT_OLED; TFT_OLED_display
Q1: IRF9Z24NPBF; TO-220-3_Horizontal_TabUp
R1: 0.3 1/4W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R101, R104, R105, R115: 1k; R_0805_2012Metric
R102: 180; R_0805_2012Metric
R106: 1.6k; R_0805_2012Metric
R107: 910; R_0805_2012Metric
R108, R121: 10k; R_0805_2012Metric
R109, R110, R123, R124, R125: 4.99k; R_0805_2012Metric
R111: 3.6k; R_0805_2012Metric
R112: 18.2k; R_0805_2012Metric
R113: 15k; R_0805_2012Metric
R114, R117: 100; R_0805_2012Metric
R116: 5.76k; R_0805_2012Metric
R118: 130k; R_0805_2012Metric
R119: 3k; R_0805_2012Metric
R120: 1.5k; R_0805_2012Metric
R122: 0.1; R_0805_2012Metric
SW1, SW3: KMR2; SW_Push_1P1T_NO_CK_KMR2
SW2: joystick-K1-1506DN-01; directional_switch_10mm
TP1: +5; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP2: +3.3; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP3: Current_limit; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP4: Boost_c; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP5: Voltage_limit; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP6: Boost_out; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP7: GND; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP8, TP9, TP10: Fiducial; Fiducial_0.75mm_Dia_1.5mm_Outer
TP11: V_lin_ctrl; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
U1: LM358P; DIP-8_W7.62mm
U2: MC33063AP1; DIP-8_W7.62mm
U101: AZ1117E-3.3; SOT-223-3_TabPin2
U102: INA199A1; SOT-363_SC-70-6
U103: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm
Y101: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C102.1, C105.1, C110.1, C111.2, C112.2, C115.1, D102.2 (A), FB101.2, J103.1 (A), J104.3 (B), R109.1, R110.1, R118.1, R120.1, SW3.1, TP2.1, U101.2 (VO), U102.3 (V+), U103.1 (VBAT), U103.24 (VDD), U103.36 (VDD), U103.48 (VDD)
+5V: C4.1, C101.1, J101.1 (VBUS), R1.2, R123.1, TP1.1, U2.6 (Vcc), U101.3 (VI); also elsewhere on the board
/Boost_out: C2.1, L2.2, Q1.3 (S), TP6.1, U1.8 (V+)
/Current_limit_divider: R113.2, R114.1, U1.2 (In1-)
/D+: J101.3 (D+), R120.2, U103.33 (PA12)
/D-: J101.2 (D-), U103.32 (PA11)
/SCK: MOD1.3 (SCK), R109.2, U103.42 (PB6)
/SDA: MOD1.4 (SDA), R110.2, U103.43 (PB7)
/SWCLK: J102.3, U103.37 (PA14)
/SWDIO: J102.1, U103.34 (PA13)
/V_boost_ctrl: C106.1, R101.1, R106.1, TP4.1
/V_curr_lim: C104.1, R105.2, R113.1, TP3.1
/V_current_amplified: U102.6 (OUT), U103.18 (PB0)
/V_lin_ctrl: C103.1, R104.1, TP11.1, U1.6 (In2-)
/V_negative_out: C1.2, J1.2, J2.2, R117.2, R122.1
/V_negative_out_offset: R117.1, R118.2, U1.3 (In1+), U102.4 (IN+)
/V_positive_out: C1.1, J1.1, J2.1, Q1.2 (D), R112.1, R116.1
/V_positive_out_div: R111.1, R112.2, U103.16 (PA6)
/Voltage_limit_divider: R115.1, R116.2, TP5.1, U1.5 (In2+)
/center: SW2.3 (center), U103.29 (PA8)
/down: SW2.6 (down), U103.27 (PB14)
/left: SW2.5 (left), U103.26 (PB13)
/right: SW2.2 (right), U103.28 (PB15)
/up: SW2.4 (up), U103.25 (PB12)
GND: C2.2, C3.2, C4.2, C5.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.1, C112.1, C113.1, C114.1, C115.2, D101.1 (K), J101.5 (GND), J101.6 (Shield), J102.2, J103.3 (B), J104.1 (A), R107.2, R111.2, R114.2, R115.2, R121.2, R122.2, R124.1, SW1.1, SW2.1 (common), TP7.1, U1.4 (V-), U2.2 (Sw_emitter), U2.4 (GND), U101.1 (GND), U102.1 (Ref), U102.2 (GND), U102.5 (IN-), U103.8 (VSSA), U103.23 (VSS), U103.35 (VSS), U103.47 (VSS); also elsewhere on the board
unnamed: C5.1, D2.1 (K), L2.1, R108.2
unnamed: C107.1, SW1.2, U103.7 (NRST)
unnamed: C108.1, U103.5 (PD0), Y101.1
unnamed: C109.1, U103.6 (PD1), Y101.2
unnamed: C113.2, C114.2, FB101.1, U103.9 (VDDA)
unnamed 30: C3.1, U2.3 (Timing_cap); also elsewhere on the board
unnamed: D1.1 (K), Q1.1 (G), R119.1
unnamed: D1.2 (A), U1.1 (Out1)
unnamed: D2.2 (A), L1.2, U2.1 (Sw_coll)
unnamed: D101.2 (A), R123.2
unnamed: D102.1 (K), R125.2
unnamed: J103.2 (C), MOD1.2 (VCC)
unnamed: J104.2 (C), MOD1.1 (GND)
unnamed 39: L1.1, R1.1, R102.2, U2.7 (Ipk_sense); also elsewhere on the board
unnamed: R101.2, U103.11 (PA1)
unnamed: R102.1, U2.8 (Drive_coll)
unnamed: R104.2, U103.13 (PA3)
unnamed: R105.1, U103.12 (PA2)
unnamed: R106.2, R107.1, R108.1, U2.5 (Comp-)
unnamed: R119.2, U1.7 (Out2)
unnamed: R121.1, U103.44 (BOOT0)
unnamed: R124.2, SW3.2, U103.20 (PB2)
unnamed: R125.1, U103.2 (PC13)

Notes on the sheet:
Power Supply
Mirco USB
3.3V Regulator
Step-Up Switching Regulator
Step-Down Linear Regulator
Ouput Connectors
Current Limiting
OLED
Joystick
Microcontroller
Current Amplifier
Signal Test Points
Power Test Points
Mounting Holes
PB2 is AKA BOOT1, which is used broken out to a pin header on the generic “blue pill” boards. An STM32duino bootloader has been written and precompiled for this configuration and is called TARGET_GENERIC_F103_PC13 in config.h. Note that the button is active high.

Board: 2 copper layers, 60.8 x 63.3 mm, 84 parts (2 on the bottom side), 48 nets.

Other parts of the board:
C116: 270pF; C_0805_2012Metric
R126: 0.3 1/4W; R_0805_2012Metric

Their connections:
+5V: R126.2; also elsewhere on the board
GND: C116.2; also elsewhere on the board
unnamed 30: C116.1; also elsewhere on the board
unnamed 39: R126.1; also elsewhere on the board

## KiCad design Power_Supply/powersupply/powersupply.kicad_pcb

Parts:
C1, C2: 100uF; CP_Radial_D6.3mm_P2.50mm
C3: 270pF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C4, C5: 470uF; CP_Radial_D10.0mm_P5.00mm
C101, C102: 1uF; C_0805_2012Metric
C103, C104: 15uF; C_0805_2012Metric
C105: .1uF; C_0805_2012Metric
D1: C503B 2.1V; LED_D3.0mm
D2, D3: 1N5819; D_DO-41_SOD81_P7.62mm_Horizontal
D101: 6V; D_SOD-123
H1, H2, H3, H4: M4; MountingHole_3.2mm_M3
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: 1x2; PinHeader_1x02_P2.54mm_Horizontal
J3: 1x2; Banana Sockets
J101: USB_B_Micro; USB_Micro-B_Amphenol_10118194-0001LF_Horizontal
L1: 47uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
L2: 1uH; 11R102C_Inductor
MOD1: TFT_OLED; TFT_OLED_display
Q1: Q_PMOS_GDS; IRF9540N-PMOS
R1: 0.1; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2: 580; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 0.3 1/4W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R101: 150; R_1206_3216Metric
R102: 180; R_0805_2012Metric
R103, R109, R110, R111: 4.99k; R_0805_2012Metric
R104, R105, R107, R115: 1k; R_0805_2012Metric
R106: 1.8k; R_0805_2012Metric
R108: 10k; R_0805_2012Metric
R112: 18.2k; R_0805_2012Metric
R113: 15k; R_0805_2012Metric
R114, R117: 100; R_0805_2012Metric
R116: 2.32k; R_0805_2012Metric
R118: 130k; R_0805_2012Metric
R119: 3k; R_0805_2012Metric
SW1: KMR2; SW_Push_1P1T_NO_CK_KMR2
SW2: joystick-K1-1506DN-01; directional_switch_10mm
TP1: +5_isolated; PinHeader_1x01_P2.54mm_Vertical
TP2: +3.3; PinHeader_1x01_P2.54mm_Vertical
TP3: Current_limit; PinHeader_1x01_P2.54mm_Vertical
TP4: Boost_c; PinHeader_1x01_P2.54mm_Vertical
TP5: Voltage_limit; PinHeader_1x01_P2.54mm_Vertical
TP6: Boost_out; PinHeader_1x01_P2.54mm_Vertical
TP7: GND; PinHeader_1x01_P2.54mm_Vertical
TP8: pin_1_alt; pads
TP9: pad_1; pads
TP10: pad_2; pads
TP11: pin_2_alt; pads
TP12: Pad1_default; pads
TP13: pin_2_pad_alt; pads
U1: B0505S-2WR2; B0505S-2WR2-Isolator
U2: MC33063AP1; DIP-8_W7.62mm
U3: LM358P; DIP-8_W7.62mm
U101: AZ1117E-3.3; SOT-223-3_TabPin2
U102: INA199; SOT-363_SC-70-6
U103: ATSAMD10D13A-SS; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
+3V3: C102.1, C105.1, MOD1.2 (VCC), R103.1, R109.1, R110.1, R118.1, TP2.1, TP8.1, TP10.1, TP13.1, U101.2 (VO), U102.3 (V+), U103.17 (VDD)
+5V: C4.1, C101.1, D101.1 (K), R2.1, R3.2, R101.2, TP1.1, U1.6 (+Vout), U2.6 (Vcc), U101.3 (VI)
/Boost_out: C2.1, L2.2, Q1.3 (S), TP6.1, U3.8 (V+)
/Current_limit_divider: R113.2, R114.1, TP3.1, U3.2 (In1-)
/SCK: MOD1.3 (SCK), R109.2, U103.10 (PA23)
/SDA: MOD1.4 (SDA), R110.2, U103.9 (PA22)
/SWCLK: J1.1, U103.12 (PA30/SWCLK)
/SWDIO: J1.3, U103.13 (PA31/SWDIO)
/USB_5V: J101.1 (VBUS), U1.1 (+Vin)
/USB_GND: J101.5 (GND), J101.6 (Shield), U1.2 (-Vin)
/V_boost_ctrl: R106.1, TP4.1, U103.18 (PA02)
/V_curr_lim: C104.1, R105.1, R113.1
/V_current_amplified: U102.6 (OUT), U103.20 (PA04)
/V_lin_ctrl: C103.1, R104.1, U3.6 (In2-)
/V_negative_out: C1.2, J2.2, J3.2, R1.1, R117.2, U102.4 (IN+)
/V_positive_out: C1.1, J2.1, J3.1, Q1.2 (D), R112.1, R116.1
/Voltage_limit_divider: R115.1, R116.2, TP5.1, U3.5 (In2+)
/center: SW2.6 (center), U103.2 (PA06)
/down: SW2.3 (down), U103.6 (PA14)
/left: SW2.2 (left), U103.3 (PA07)
/right: SW2.5 (right), U103.1 (PA05)
/up: SW2.1 (up), U103.7 (PA15)
GND: C2.2, C3.2, C4.2, C5.2, C101.2, C102.2, C103.2, C104.2, C105.2, D1.1 (K), D101.2 (A), J1.2, MOD1.1 (GND), R1.2, R101.1, R107.2, R111.2, R114.2, R115.2, SW1.1, SW2.4 (common), TP7.1, TP9.1, TP11.1, TP12.1, U1.4 (-Vout), U2.2 (Sw_emitter), U2.4 (GND), U3.4 (V-), U101.1 (GND), U102.1 (Ref), U102.2 (GND), U102.5 (IN-), U103.16 (GND)
unnamed: C3.1, U2.3 (Timing_cap)
unnamed: C5.1, D2.1 (K), L2.1, R108.2
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), L1.2, U2.1 (Sw_coll)
unnamed: D3.1 (K), Q1.1 (G), R119.1
unnamed: D3.2 (A), U3.1 (Out1)
unnamed: L1.1, R3.1, R102.2, U2.7 (Ipk_sense)
unnamed: R102.1, U2.8 (Drive_coll)
unnamed: R103.2, SW1.2, U103.11 (PA28/~RST)
unnamed: R104.2, U103.14 (PA24)
unnamed: R105.2, U103.15 (PA25)
unnamed: R106.2, R107.1, R108.1, U2.5 (Comp-)
unnamed: R111.1, R112.2, U103.8 (PA16)
unnamed: R117.1, R118.2, U3.3 (In1+)
unnamed: R119.2, U3.7 (Out2)

Notes on the sheet:
Power Supply
Mirco USB
2W Isolator
3.3V Regulator
Step-Up Switching Regulator
Step-Down Linear Regulator
Ouput Connectors
Current Limiting
OLED
Joystick
Programming Pin Headers
Microcontroller
Current Amplifier
Signal Test Points
Power Test Points
Mounting Holes

Board: 2 copper layers, 60.8 x 63.3 mm, 69 parts (6 on the bottom side), 38 nets.

## KiCad design Wave_Generator/wavegenerator/wavegenerator.kicad_pcb

File Wave_Generator/README.md:

# Wave Generator
This wave generator was created around the MAX038 chip 

## Details

* If you would like to see the files associated with the PCB design and manufacturing please visit the [wavegenerator_version_1 folder](wavegenerator_version_1/)

* To get in depth instructions on how to solder, program, and test/debug your wave generator visit the [instructions](instructions.pdf)

* If you would like to attempt the Surface Mount version of this project but you have not used this technique before, see [this]() video for a quick tutorial and make sure you have some assistance.

Parts:
C1, C2: 220uF 10V; CP_Radial_D8.0mm_P2.50mm
C3, C8: 4.7uF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C4, C5, C9: 1uF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C6: 470pF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C7: 47nF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C101, C102: 100nF; C_0805_2012Metric
C103: 560pF; C_0805_2012Metric
C104, C105: 12pF; C_0805_2012Metric
C106, C107: 1uF; C_0805_2012Metric
D101: 1N5819; D_SOD-123
H1, H2, H3, H4: 2.1mm; MountingHole_3.2mm_M3
J1: 01x05; 01x05_pin_header
J3: Conn_Coaxial; BNC_connector_731000105
J4: 1x2Pinheader; PinSocket_1x02_P2.54mm_Vertical
J101: USB_B_Micro; USB_Micro-B_Amphenol_10118194-0001LF_Horizontal
L101: 82uH; L_7.3x7.3_H3.5
MOD1: TFT_LCD; TFT_LCD_ST7735
R1, R2: 182k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 4.87k 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 1.5M 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 182k 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 549 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8, R9: 549; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R101: 1.5; R_0805_2012Metric
R102: 3.32k 1%; R_0805_2012Metric
R103: 10k 1%; R_0805_2012Metric
R104: 10k; R_0805_2012Metric
RV1: 1M; Potentiometer_PTV09A
RV2: 20k; Potentiometer_PTV09A
RV3: 1k; Potentiometer_PTV09A
SW1, SW2: button; SW_PUSH_6mm
SW3: SP3T; SP3T_OS103011MS8QP1
TP1: 3.3 V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP2: freq; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP3: -5V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP4: +5 V; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP5: WS_0; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP6: WS_1; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP7: MAX038 Out; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
TP8: GND; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
U1: MAX038CPP; MAX038CPP-W
U101: AZ1117E-3.3; SOT-223-3_TabPin2
U102: MC33063AD; SOIC-8_3.9x4.9mm_P1.27mm
U103: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Y101: 16MHz; Crystal_SMD_ECS_CSM3X-2Pin_7.6x4.1mm

Connections:
+3V3: C102.2, C107.1, MOD1.2, MOD1.8, R1.1, R104.1, TP1.1, U101.2 (VO), U103.4 (VCC), U103.6 (VCC), U103.18 (AVCC)
+5V: C1.1, C4.1, C106.1, J101.1 (VBUS), R101.2, TP4.1, U1.17, U101.3 (VI), U102.6 (Vin)
-5V: C2.2, C5.1, C103.2, D101.2 (A), R102.2, TP3.1, U1.20, U102.4 (GND)
/CS: MOD1.7, U103.32 (PD2)
/DC: MOD1.6, U103.1 (PD3)
/MAX038_output: C3.2, R8.1, RV3.3, TP7.1, U1.19
/MISO: J1.1, U103.16 (PB4)
/MOSI: J1.3, MOD1.4, U103.15 (PB3)
/SCK: J1.2, MOD1.3, U103.17 (PB5)
/WS_0: TP5.1, U1.3, U103.10 (PD6)
/WS_1: TP6.1, U1.4, U103.11 (PD7)
/freq: C3.1, R1.2, R2.1, TP2.1, U103.9 (PD5), U103.12 (PB0)
/output: J3.1 (In), J4.1, R9.1
/reset: J1.4, R104.2, SW2.1, U103.29 (~RESET~/PC6)
/reset_lcd: MOD1.5, U103.28 (PC5)
/switch_n: SW1.1, U103.2 (PD4)
GND: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C101.2, C102.1, C104.1, C105.2, C106.2, C107.2, J1.5, J3.2 (Ext), J4.2, J101.5 (GND), J101.6 (Shield), L101.2, MOD1.1, R2.2, R7.2, R103.2, RV3.1, SW1.2, SW2.2, TP8.1, U1.6, U1.8, U1.9, U1.11, U1.12, U1.15, U101.1 (GND), U103.3 (GND), U103.5 (GND), U103.21 (GND)
unnamed: C6.1, SW3.4
unnamed: C7.1, SW3.3
unnamed: C8.1, SW3.1
unnamed: C9.1, R4.2, R6.1, RV1.1, RV1.2, U1.1
unnamed: C101.1, U103.20 (AREF)
unnamed: C103.1, U102.3 (TC)
unnamed: C104.2, U103.7 (XTAL1/PB6), Y101.2
unnamed: C105.1, U103.8 (XTAL2/PB7), Y101.1
unnamed: D101.1 (K), L101.1, U102.2 (SwE)
unnamed: R3.1, U1.10
unnamed: R3.2, R4.1, RV1.3
unnamed: R5.1, R6.2, RV2.3
unnamed: R5.2, RV2.1, RV2.2, U1.7
unnamed: R7.1, R8.2, R9.2, RV3.2
unnamed: R101.1, U102.1 (SwC), U102.7 (Ipk), U102.8 (DC)
unnamed: R102.1, R103.1, U102.5 (Vfb)
unnamed: SW3.2, U1.5

Notes on the sheet:
Microcontroller
LCD Module
Function Generator
Power Supplies
Mounting Holes
Test Points
5V USB Bus
3.3V Linear Regulator
Programming Pin Headers
Output Connectors
Frequency Band Adjust
Wavegenerator
July 15th, 2019
1.0
-5V Inverter
Amplitude Controller
